# Keil uVision project Eink.uvprojx, settings and files
target Eink Configuration (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ELINK
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_rcc.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal.c stm32f2xx_hal_dma.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_pwr_ex.c
  group Hardware
    ../Hardware/: flash.c spi.c 24l01.c Eink.c Uart.c EXTI.c IIC.c TPS65185.c pic.c
    ../Src/: nRF24L01_bsp.c nRF24L01.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f205xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Application/User
    ../Src/: main.c stm32f2xx_it.c stm32f2xx_hal_msp.c
  group Library
    ../Lib/: STD_HAL.lib
  group test_src
    ./: testsrc.c
software components: CMSIS:CORE 4.3.0
